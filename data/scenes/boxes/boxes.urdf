Commit message: boxes environment settings

File: data/scenes/boxes/boxes.urdf (robot description, URDF)
Before this commit: robot bookshelves, 1 links, 0 joints
Links:
- link bookshelf: geometry collision mesh filename=boxes-new.obj; visual mesh filename=boxes-new.obj
