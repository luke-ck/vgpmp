Commit message: move lab files to their own folder

File: data/scenes/lab/lab_mesh.urdf (robot description, URDF)
Before this commit: robot bookshelves_table, 1 links, 0 joints
Links:
- link bookshelf: geometry collision mesh filename=lab.obj; visual mesh filename=lab.obj
